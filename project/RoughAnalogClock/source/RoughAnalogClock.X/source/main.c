/*******************************************************************************
*	Author		|	Date		|	FileName
*-------------------------------------------------------------------------------
*	kenchaan	|	2019/09/09	|	main.c
*-------------------------------------------------------------------------------
*	Description	|	main
*-------------------------------------------------------------------------------
*	Copyright (c) 2019 kenchaan All Rights Reserved.
*******************************************************************************/

/*------------------------------------------------------------------------------
*	include
*-----------------------------------------------------------------------------*/
#include <xc.h>
#include "types.h"
#include "hardware.h"
#include "hardware_port.h"
#include "application.h"

/*------------------------------------------------------------------------------
*	pragma
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	define
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	macro
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	typedef
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	enum
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	struct
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	static variable
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	static function prototype
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	static const data
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	extern const data
*-----------------------------------------------------------------------------*/


/*------------------------------------------------------------------------------
*	function
*-----------------------------------------------------------------------------*/

/*------------------------------------------------------------------------------
* OverView	: main
* Parameter	: None
* Return	: None
*-----------------------------------------------------------------------------*/
void main( void )
{
	U32 i;

	HW_Initialize();
	APP_Initialize();

	HW_StartProcess();

	for( i = 0; i < 300; i++ ){
		HW_WaitFrameStart();
		HW_PORT_ActivateAll( TRUE );
	}
	for( i = 0; i < 150; i++ ){
		HW_WaitFrameStart();
		HW_PORT_ActivateAll( FALSE );
	}

	while( TRUE ){
		HW_WaitFrameStart();

		HW_FramePreProcess();
		APP_FramePreProcess();

		HW_FrameMainProcess();
		APP_FrameMainProcess();

		HW_FramePostProcess();
		APP_FramePostProcess();
	}
}


/*------------------------------------------------------------------------------
*	End Of File
*-----------------------------------------------------------------------------*/
